# Keil uVision project iTFLS-Card.uvproj, settings and files
target 0.0.1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: iTFLSCardSoftware +hex
  c flags: Optimize=8 SizeSpeed=1
  group lcd1602
    ./SourceCode/lcd1602/: lcd1602.c lcd1602.h
  group keyboard
    ./SourceCode/keyboard/: keyboard.c keyboard.h
  group main&config
    ./SourceCode/: main.c config.h
  group common
    ./SourceCode/common/: common.c common.h
  group serialPort
    ./SourceCode/serialPort/: serialPort.c serialPort.h
  group MFRC500
    ./SourceCode/MFRC500/: MFRC500.c MFRC500.h MFRC500Functions.c
  group buzzer
    ./SourceCode/buzzer/: buzzer.c buzzer.h
